# Keil uVision project spin_coating.uvprojx, settings and files
target Spin Coater (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\board_config\Inc;..\components;..\control_algorithms;..\core;..\docs_example;..\drivers;..\modes;..\protocol_uart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: main.c main.h
  group board_config
    ../board_config/Inc/: pinmap.h
  group drivers
    ../drivers/: delay.c delay.h uart.c uart.h
  group components
    ../components/: encoder.c encoder.h esc_driver.c esc_driver.h io_driver.c io_driver.h
  group control_algorithms
    ../control_algorithms/: kalmanfilter.c kalmanfilter.h pid.c pid.h
  group modes
    ../modes/: coater.c coater.h mode.c mode.h
  group protocol_uart
    ../protocol_uart/: convert.c convert.h message.c message.h protocol_uart.c protocol_uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
